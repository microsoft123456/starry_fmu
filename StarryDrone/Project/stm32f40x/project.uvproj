# Keil uVision project project.uvproj, settings and files
target rt-thread_stm32f4xx (ARM-ADS)
  device: STM32F427VI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: starry +hex
  AfterMake: fromelf --bin !L --output build/starry_drone.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F427X
  c misc: --c99 --gnu
  c include: ..\..\Library\STM_Lib\STM32F4xx_StdPeriph_Driver\inc;..\..\Library\STM_Lib\CMSIS\Include;..\..\Library\STM_Lib\CMSIS\Device\ST\STM32F4xx\Include;..\..\Library\mavlink\v2.0;..\..\Library\mavlink\v2.0\common;..\..\Driver\usb\inc;..\..\Driver\include;..\..\RTOS\components\finsh;..\..\RTOS\libcpu\arm\common;..\..\RTOS\libcpu\arm\cortex-m4;..\..\RTOS\include;..\..\HAL\include;..\..\Framework\include;..\stm32f40x
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1fc000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    ../../Application/: application.c startup.c
  group Framework
    ../../Framework/source/Control/: control.c pid.c
    ../../Framework/source/EKF/: ekf.c
    ../../Framework/source/Filter/: filter.c FIR.c
    ../../Framework/source/INS/: attitude.c kalman.c mix.c position.c
    ../../Framework/source/LED/: led.c
    ../../Framework/source/Log/: log.c
    ../../Framework/source/Mavlink/: mavlink_protocol.c
    ../../Framework/source/Param/: param.c
    ../../Framework/source/PX4IO/: px4io_manager.c px4io_protocol.c px4io_uploader.c
    ../../Framework/source/RC/: rc_receiver.c
    ../../Framework/source/Sensor/: calibration.c sensor.c
    ../../Framework/source/Time/: delay.c
    ../../Framework/source/Tool/: ringbuffer.c
  group Math
    ../../Framework/source/Math/: ap_math.c light_matrix.c quaternion.c
  group HAL
    ../../HAL/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../HAL/motor/: motor.c
    ../../HAL/pin/: pin.c
    ../../HAL/printf/: printf.c
    ../../HAL/rc_receiver/: rc_receiver.c
    ../../HAL/serial/: serial.c
    ../../HAL/spi/: spi_core.c spi_dev.c
    ../../HAL/tools/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
    ../../HAL/usb/: cdcacm.c
  group Driver
    ../../Driver/board/: board.c
    ../../Driver/: stm32f4xx_it.c
    ../../Driver/gpio/: gpio.c
    ../../Driver/gps/: gps.c
    ../../Driver/hw_timer/: drv_hwtimer.c
    ../../Driver/i2c/: i2c_soft.c
    ../../Driver/l3gd20h/: l3gd20h.c
    ../../Driver/lsm303d/: lsm303d.c
    ../../Driver/ms5611/: ms5611.c
    ../../Driver/pwm/: pwm.c
    ../../Driver/rtc/: stm32f4_rtc.c
    ../../Driver/spi/: stm32f4_spi.c
    ../../Driver/usart/: usart.c
  group usb
    ../../Driver/usb/src/: usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usbd_cdc_core_loopback.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usbd_usr.c
  group finsh
    ../../RTOS/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group Kernel
    ../../RTOS/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group STM32_StdPeriph
    ../../Library/STM_Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../Library/STM_Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group CORTEX-M4
    ../../RTOS/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../RTOS/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../Library/STM_Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427x.s
