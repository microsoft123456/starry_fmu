# Keil uVision project project.uvproj, settings and files
target rt-thread_stm32f4xx (ARM-ADS)
  device: STM32F427VI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: starry_drone +hex
  AfterMake: fromelf --bin !L --output starry.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F427X
  c misc: --c99 --gnu
  c include: Libraries/STM32F4xx_StdPeriph_Driver/inc;Libraries/CMSIS/ST/STM32F4xx/Include;Libraries/CMSIS/Include;applications;.;drivers;..\..\include;..\..\libcpu\arm\cortex-m4;..\..\libcpu\arm\common;..\..\components\drivers\include;..\..\components\finsh;..\..\components\drivers\include\drivers;..\..\components\drivers\include;..\..\mavlink\v2.0;..\..\mavlink\v2.0\common;.\framework;..\..\components\drivers\usb\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1fc000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: application.c startup.c
  group Framework
    ./framework/: calibration.c delay.c led.c sensor.c attitude.c quaternion.c ap_math.c mix.c param.c filter.c mavlink_protocol.c Sensor_Manager.c px4io_uploader.c ringbuffer.c px4io_manager.c px4io_protocol.c control.c pid.c kalman.c cdcacm.c log.c
  group Device_HAL
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../components/drivers/sensors/: lsm303d_sensor.c l3gd20h_sensor.c ms5611_sensor.c gps_sensor.c
    ../../components/drivers/printf/: printf.c
    ../../components/drivers/rc_receiver/: rc_receiver.c
    ../../components/drivers/motor/: motor.c
  group Board_Drivers
    drivers/: board.c stm32f4xx_it.c usart.c gpio.c
    ./drivers/: stm32f4_rtc.c i2c_soft.c stm32f4_spi.c pwm.c
  group usb
    ../../components/drivers/usb/src/: usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usb_otg.c usbd_cdc_core.c usbd_cdc_core_loopback.c usbd_cdc_if_template.c usbd_cdc_vcp.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usbd_usr.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c msh.c msh_cmd.c msh_file.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group STM32_StdPeriph
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427x.s
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
